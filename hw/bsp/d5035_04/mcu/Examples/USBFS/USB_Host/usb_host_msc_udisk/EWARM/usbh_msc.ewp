# IAR project usbh_msc.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32C103xB GD GD32C103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32C10X; GD32C103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32C10x\Include; ..\..\..\..\..\Firmware\GD32C10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\host\class\msc\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\ustd\class\msc; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.srec
  ILINK.IlinkOutputFile: usbh_msc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32c10x_it.c gd32c10x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group GD32C10x_EVAL
    ../src/: gd32c103v_lcd_eval.c lcd_font.c lcd_log.c
    ../../../../../Utilities/: gd32c10x_eval.c
  group GD32C10x_Peripherals
    ../../../../../Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_gpio.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_timer.c gd32c10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32C10x/Source/IAR/: startup_gd32c10x.s
  group USB_Class
    ../../../../../Firmware/GD32C10x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Drivers
    ../../../../../Firmware/GD32C10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32C10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
