# IAR project hid_printer.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32C103xB GD GD32C103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32C10X; GD32C103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32C10x\Include; ..\..\..\..\..\Firmware\GD32C10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\device\class\printer\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\ustd\class\hid; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: hid_printer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c custom_hid_itf.c gd32c10x_hw.c gd32c10x_it.c hid_printer_wrapper.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Doc
    ../: readme.txt
  group GD32C10x_EVAL
    ../../../../../Utilities/: gd32c10x_eval.c
  group GD32C10x_StdPeriph
    ../../../../../Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_ctc.c gd32c10x_dma.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_gpio.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_timer.c gd32c10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32C10x/Source/IAR/: startup_gd32c10x.s
  group USB_Class
    ../../../../../Firmware/GD32C10x_usbfs_library/device/class/hid/Source/: custom_hid_core.c
    ../../../../../Firmware/GD32C10x_usbfs_library/device/class/printer/Source/: printer_core.c
  group USB_Device
    ../../../../../Firmware/GD32C10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32C10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
