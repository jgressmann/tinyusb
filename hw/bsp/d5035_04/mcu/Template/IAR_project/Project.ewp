# IAR project Project.ewp, settings and files
configuration GD32C10X (ARM, debug)
  General.OGChipSelectEditMenu: GD32C103xB GD GD32C103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32C10X; GD32C103V_EVAL
  ICCARM.CCIncludePath2: ..\..\Firmware\CMSIS; ..\..\Utilities; ..; ..\..\Firmware\GD32C10x_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32C10x\Include; ..\..\Utilities\LCD_Commom
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32C103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32c10x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Doc
    ../: readme.txt
  group GD32C10x_EVAL
    ../../Utilities/: gd32c10x_eval.c gd32c10x_lcd_eval.c
    ../../Utilities/LCD_Commom/: lcd_font.c
  group GD32C10x_Peripherals
    ../../Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32C10x/Source/IAR/: startup_gd32c10x.s
